# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\third_lib\freertos\include;..\third_lib\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac5.sct
  group app
    ../app/: FreeRTOSConfig.h main.c
  group third_lib/freertos
    ../third_lib/freertos/include/: FreeRTOS.h portable.h list.h task.h
    ../third_lib/freertos/portable/RVDS/ARM_CM3/: portmacro.h port.c
    ../third_lib/freertos/: list.c task.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.3
